# Keil uVision project conecta4_2022.uvproj, settings and files
target conecta4_2022 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: conecta4_2022
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  link misc: --entry 0x0
  group Startup Code
    ./: Startup.s
  group Source Code
    ./: main.c cola_asyn.c conecta4_2022.c temporizador.c cola_msg.c gpio.c botones.c g_energia.c g_io.c g_alarmas.c g_boton.c semaforo_interrupciones.c power.c
  group Headers
    ./: utils.h gpio.h cola_asyn.h cola_msg.h temporizador.h botones.h g_alarmas.h g_energia.h g_io.h g_boton.h celda.h conecta4_2022.h semaforo_interrupciones.h power.h msg.h eventos.h
  group Assembly Code
    ./: conecta4_buscar_alineamiento_arm.s conecta4_hay_linea_arm_arm.s conecta4_hay_linea_arm_c.s
